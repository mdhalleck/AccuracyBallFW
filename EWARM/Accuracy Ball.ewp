# IAR project Accuracy Ball.ewp, settings and files
configuration AccuracyBall (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RC ST STM32F411RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F401xE; USE_STM32F4XX_NUCLEO; USE_HAL_DRIVER; ENABLE_SPI_FIX; BLUENRG_MS
  ICCARM.CCIncludePath2: Inc; ..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\BSP\STM32F4xx-Nucleo; ..\Drivers\BSP\X-NUCLEO-IDB04A1; ..\Drivers\BSP\X_NUCLEO_IKS01A1; ..\Drivers\BSP\Components\Common; ..\Drivers\BSP\Components\lps25h; ..\Drivers\BSP\Components\hts221; ..\Drivers\BSP\Components\lis3mdl; ..\Drivers\BSP\Components\lps25hb; ..\Drivers\BSP\Components\lsm6ds0; ..\Drivers\BSP\Components\lsm6ds3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SensorDemoProject.bin
  ILINK.IlinkOutputFile: SensorDemoProject.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f401xe.s
  group Application/User
    Src/: Accuracy_Ball.c bluenrg_interface.c clock.c cube_hal_f4.c H3LIS331DL.c main.c sensor_service.c stm32xx_it.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/hts221/: hts221.c
    ../Drivers/BSP/Components/lis3mdl/: lis3mdl.c
    ../Drivers/BSP/Components/lps25h/: lps25h.c
    ../Drivers/BSP/Components/lps25hb/: lps25hb.c
    ../Drivers/BSP/Components/lsm6ds0/: lsm6ds0.c
    ../Drivers/BSP/Components/lsm6ds3/: lsm6ds3.c
  group Drivers/BSP/STM32F4xx_NUCLEO
    ../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDB04A1
    ../Drivers/BSP/X-NUCLEO-IDB04A1/: stm32_bluenrg_ble.c
  group Drivers/BSP/X_NUCLEO_IKS01A1
    ../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_hum_temp.c x_nucleo_iks01a1_imu_6axes.c x_nucleo_iks01a1_magneto.c x_nucleo_iks01a1_pressure.c
  group Drivers/CMSIS
    Src/: system_stm32f4xx.c
    ../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c
  group Middlewares/STM32_BlueNRG/HCI
    ../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c
  group Middlewares/STM32_BlueNRG/HCI/controller
    ../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c
  group Middlewares/STM32_BlueNRG/Interface
    ../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf_template.c
  group Middlewares/STM32_BlueNRG/Utils
    ../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: gp_timer.c list.c osal.c
